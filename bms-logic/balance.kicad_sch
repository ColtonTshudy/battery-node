File: bms-logic/balance.kicad_sch (KiCad schematic)
At the start: 5 parts, among them Q5 PBSS4350T,215

Commit message: started afe layout
Parts:
- renumbered C21 to C17
